# Keil uVision project Air-conditionSystem.uvprojx, settings and files
target 空调控制系统 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Air-conditionSystem +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,xUSE_IWDG,xPOTENTIOMETER,xPT100
  c include: ..\source\app;..\source\boards;..\source\boards\hardware;..\source\boards\hardware\inc;..\source\boards\mcu\CM3;..\source\boards\mcu\STM32;..\source\boards\mcu\STM32\LIB\inc;..\source\peripherals;..\source\peripherals\inc;..\source\system;..\source\WiFiToCloud
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../source/app/: main.c stm32App.c stm32f103_config.h
  group boards\hardware
    ../source/boards/hardware/src/: hal_buzzer.c hal_iic.c hal_iic1.c hal_key.c hal_timer2.c hal_uart4.c hal_usart1.c
  group boards\cmsis
    ../source/boards/mcu/CM3/: core_cm3.c
    ../source/boards/mcu/STM32/: stm32f10x_it.c system_stm32f10x.c
    ../source/boards/mcu/STM32/STARTUP/: startup_stm32f10x_hd.s
  group boards\stm32
    ../source/boards/mcu/STM32/LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group peripherals
    ../source/peripherals/src/: 74hc595.c lcd12864.c ledNixietube.c NTCthermistor.c pcf8563.c pcf8591.c pt100.c remote.c
  group system
    ../source/system/: delay.c sys.c
  group WiFi To Cloud
    ../source/WiFiToCloud/: DateAndTime.c HAL_WiFiToCloud.c WiFiToCloud.c CloudReference.h
  group readme
    ../: IO口定义说明.h
